# Keil uVision project uartrecv.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F401CCFx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uartrecv +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./MCAL/MEXTI/: MEXTI_Proc.c
    ./MCAL/MGPIO/: MGPIO_Proc.c
    ./MCAL/MNVIC/: MNVIC_PROC.c
    ./MCAL/MRCC/: MRCC_PROC.c
    ./MCAL/MSYSTICK/: MSYSTICK_Proc.c
    ./MCAL/MUSART/: MUSART_proc.c
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
